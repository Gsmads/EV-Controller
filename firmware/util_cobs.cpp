/**
 * @file util_cobs.cpp
 * @brief Реализация COBS
 *
 * Кодирование разбивает вход на группы, разделённые нулями. Каждая
 * группа предваряется байтом-кодом: расстояние до следующего нуля.
 * Код 0xFF означает «группа из 254 ненулевых байт и нуля за ней нет» —
 * так кодируются длинные участки без нулей.
 *
 * Разбор на примерах:
 *   {}                  -> 01
 *   {00}                -> 01 01
 *   {11 22}             -> 03 11 22
 *   {11 00 22}          -> 02 11 02 22
 *   254 ненулевых байта -> FF <254 байта>
 *
 * Прибавка длины: один байт на кадр плюс по одному на каждые полные
 * 254 байта данных.
 */
#include "util_cobs.h"

#include <stddef.h>  /* NULL */

int16_t util_cobs_encode(const uint8_t *src, uint8_t len,
                         uint8_t *dst, uint16_t cap)
{
    if (src == NULL || dst == NULL || cap < 1) return -1;

    uint16_t out      = 1;   /* dst[0] зарезервирован под первый байт-код */
    uint16_t code_pos = 0;   /* куда записать код текущей группы */
    uint8_t  code     = 1;   /* длина группы плюс один */
    uint8_t  slot_open = 1;  /* code_pos ещё не заполнен */

    for (uint8_t i = 0; i < len; i++) {
        uint8_t b = src[i];

        if (b != 0) {
            if (out >= cap) return -1;
            dst[out++] = b;
            code++;
            if (code != 0xFF) continue;   /* группа ещё не заполнена */
        }

        /* Группа закрывается: либо встретился ноль, либо набрались 254 байта */
        dst[code_pos] = code;
        slot_open = 0;
        code = 1;

        /* Новый слот под код нужен, только если дальше что-то будет
           закодировано. Ноль сам по себе требует представления, поэтому
           после нуля слот нужен всегда; после переполнения группы —
           лишь если остались входные байты. Без этой проверки кодер
           писал бы лишний байт за пределом возвращаемой длины. */
        if (b == 0 || (uint16_t)(i + 1) < (uint16_t)len) {
            if (out >= cap) return -1;
            code_pos = out++;
            slot_open = 1;
        }
    }

    if (slot_open) {
        dst[code_pos] = code;
    }
    return (int16_t)out;
}

int16_t util_cobs_decode(const uint8_t *src, uint8_t len,
                         uint8_t *dst, uint16_t cap)
{
    if (src == NULL || dst == NULL) return -1;

    uint16_t out = 0;
    uint16_t i   = 0;

    while (i < len) {
        uint8_t code = src[i++];

        /* Ноль внутри закодированных данных невозможен по построению:
           если он там есть, значит это не кадр, а мусор или обрывок. */
        if (code == 0) return -1;

        for (uint8_t k = 1; k < code; k++) {
            if (i >= len)   return -1;   /* группа обещала больше, чем пришло */
            if (out >= cap) return -1;
            /* Ноль не может стоять и внутри группы: закодированные данные
               нулей не содержат вовсе. Без этой проверки испорченный байт
               молча уезжал бы в результат как полезные данные. */
            if (src[i] == 0) return -1;
            dst[out++] = src[i++];
        }

        /* Код меньше 0xFF означает, что за группой стоял ноль. Последняя
           группа кадра исключение: за ней стоит разделитель, а не данные. */
        if (code != 0xFF && i < len) {
            if (out >= cap) return -1;
            dst[out++] = 0;
        }
    }

    return (int16_t)out;
}
